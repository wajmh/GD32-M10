# Keil uVision project GD32L233C_START.uvprojx, settings and files
target GD32L233C_START (6210000::V6.21::ARMCLANG)
  device: GD32L233RC GigaDevice
  pack: GigaDevice.GD32L23x_DFP.1.1.0
  cpu: IRAM(0x20000000,0x0008000) IROM(0x08000000,0x0040000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\GD32L23x_Firmware_Library\CMSIS\GD\GD32L23x\Include;..\..\..\..\GD32L23x_Firmware_Library\GD32L23x_standard_peripheral\Include;..\..\..\Utilities;..\;.\EPD;.\Fonts;.\GUI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c gd32l23x_it.c systick.c
  group CMSIS
    ../../../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/: system_gd32l23x.c
  group GD32L23x_Peripherals
    ../../../../GD32L23x_Firmware_Library/GD32L23x_standard_peripheral/Source/: gd32l23x_adc.c gd32l23x_cau.c gd32l23x_cau_aes.c gd32l23x_cau_des.c gd32l23x_cau_tdes.c gd32l23x_cmp.c gd32l23x_crc.c gd32l23x_ctc.c gd32l23x_dac.c gd32l23x_dbg.c gd32l23x_dma.c gd32l23x_exti.c gd32l23x_fmc.c gd32l23x_fwdgt.c gd32l23x_gpio.c gd32l23x_i2c.c gd32l23x_lptimer.c gd32l23x_lpuart.c gd32l23x_misc.c gd32l23x_pmu.c gd32l23x_rcu.c gd32l23x_rtc.c gd32l23x_slcd.c gd32l23x_spi.c gd32l23x_syscfg.c gd32l23x_timer.c gd32l23x_trng.c gd32l23x_usart.c gd32l23x_vref.c gd32l23x_wwdgt.c
  group GD32L23x_START
    ../../../Utilities/: gd32l233c_start.c
  group Startup
    ../../../../GD32L23x_Firmware_Library/CMSIS/GD/GD32L23x/Source/ARM/: startup_gd32l23x.s
  group EPD
    ./EPD/: Ap_29demo.h Display_EPD_W21.c Display_EPD_W21.h Display_EPD_W21_spi.c Display_EPD_W21_spi.h Motor.c Motor.h Uart.c Uart.h demo.c
  group Fonts
    ./Fonts/: font8.c font12.c font12CN.c font16.c font20.c font24.c font24CN.c fonts.h
  group GUI
    ./GUI/: GUI_Paint.c GUI_Paint.h
software components: CMSIS:CORE 5.6.0
